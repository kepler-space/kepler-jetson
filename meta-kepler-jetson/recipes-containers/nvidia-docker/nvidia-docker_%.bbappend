FILESEXTRAPATHS:prepend := "${THISDIR}/${BPN}:"
SRC_URI += "file://0001-Set-data-root.patch \
            file://0002-Set-mtu.patch \
"
