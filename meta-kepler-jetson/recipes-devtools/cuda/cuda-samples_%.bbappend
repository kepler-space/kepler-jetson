DEPENDS += "cuda-profiler-api"

CUDA_SAMPLES = "Samples/0_Introduction/matrixMul"
